# Set a short, predictable mDNS-friendly hostname so avahi-daemon
# publishes the board as luckfox-pico.local instead of the verbose
# luckfox-pico-ultra-w.local that MACHINE would otherwise produce.
hostname:luckfox-pico-ultra-w = "luckfox-pico"
